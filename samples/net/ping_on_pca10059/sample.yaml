## samples/net/ping_on_pca10059/sample.yaml
```yaml
common:
  harness: net
  tags: net
sample:
  description: Test core network features
  name: ping
```
